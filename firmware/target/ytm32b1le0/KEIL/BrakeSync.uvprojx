# Keil uVision project BrakeSync.uvprojx, settings and files
target BrakeSync (6240000::V6.24::ARMCLANG)
  device: YTM32B1LE05 YTMicro
  pack: YTMicro.YTM32B1LE0_DFP.1.4.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) IROM2(0x10000000,0x800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BrakeSync +hex
  AfterMake: fromelf --bin --bincombined --output=Objects\@L.bin !L
  AfterMake: fromelf --m32 --m32combined --output=Objects\@L.srec !L
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: YTM32B1LE0,CPU_YTM32B1LE0,
  c include: ../../../bsw/board/ytm32b1le0/generated;../../../bsw/mcal/ytm32b1le0/sdk/platform/drivers/src/clock/YTM32B1Lx;../../../bsw/mcal/ytm32b1le0/sdk/platform/drivers/src/pins;../../../bsw/mcal/ytm32b1le0/sdk/platform/drivers/src/dma;../../../bsw/mcal/ytm32b1le0/sdk/platform/drivers/src/uart;../../../bsw/mcal/ytm32b1le0/sdk/platform/drivers/inc;../../../bsw/mcal/ytm32b1le0/sdk/platform/devices/common;../../../bsw/mcal/ytm32b1le0/sdk/platform/devices;../../../bsw/mcal/ytm32b1le0/sdk/platform/devices/YTM32B1LE0/include;../../../bsw/mcal/ytm32b1le0/sdk/platform/devices/YTM32B1LE0/startup;../../../bsw/mcal/ytm32b1le0/sdk/CMSIS/Core/Include;../../../bsw/mcal/ytm32b1le0/sdk/rtos/osif;../../../asw/app;../../../bsw/board/ytm32b1le0;../../../bsw/services;../../../bsw/mcal/include;../../../bsw/board/ytm32b1le0/bringup
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ../../../bsw/board/ytm32b1le0/generated/yt_linker.scf
  link misc: --entry Reset_Handler --no_startup --diag_suppress=L6314W,L6221E,L6329W --keep=*(.isr_vector)
  group ASW
    ../../../asw/app/: main.c app.c app.h
  group BSW
    ../../../bsw/board/ytm32b1le0/: board_support.c board_support.h
    ../../../bsw/board/ytm32b1le0/generated/: clock_config.c clock_config.h pin_mux.c pin_mux.h interrupt_config.c interrupt_config.h dma_config.c dma_config.h uart_config.c uart_config.h sdk_project_config.h RamInit0.S RamInit1.c RamInit2.c startup.S vector.S vector_table_copy.c
    ../../../bsw/mcal/include/: mcal_time.h
    ../../../bsw/mcal/ytm32b1le0/: mcal_time.c
    ../../../bsw/mcal/ytm32b1le0/sdk/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_ccarm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ../../../bsw/mcal/ytm32b1le0/sdk/platform/devices/: callbacks.h devassert.h device_registers.h floats.h status.h
    ../../../bsw/mcal/ytm32b1le0/sdk/platform/devices/common/: core_common.h
    ../../../bsw/mcal/ytm32b1le0/sdk/platform/devices/YTM32B1LE0/include/: YTM32B1LE0.h YTM32B1LE0_features.h
    ../../../bsw/mcal/ytm32b1le0/sdk/platform/drivers/inc/: clock.h clock_manager.h pins_driver.h interrupt_manager.h dma_driver.h uart_driver.h
    ../../../bsw/mcal/ytm32b1le0/sdk/platform/drivers/src/clock/YTM32B1Lx/: cfmu_hw_access.h clock_YTM32B1Lx.c clock_YTM32B1Lx.h cmu_hw_access.h ipc_hw_access.h scu_hw_access.h
    ../../../bsw/mcal/ytm32b1le0/sdk/platform/drivers/src/dma/: dma_driver.c dma_hw_access.c dma_hw_access.h dma_irq.c dma_irq.h
    ../../../bsw/mcal/ytm32b1le0/sdk/platform/drivers/src/interrupt/: interrupt_manager.c
    ../../../bsw/mcal/ytm32b1le0/sdk/platform/drivers/src/pins/: pins_driver.c pins_gpio_hw_access.h pins_port_hw_access.c pins_port_hw_access.h
    ../../../bsw/mcal/ytm32b1le0/sdk/platform/drivers/src/uart/: uart_driver.c uart_irq.c uart_irq.h uart_hw_access.h uart_hw_access.c
    ../../../bsw/mcal/ytm32b1le0/sdk/rtos/osif/: osif.h osif_baremetal.c
    ../../../bsw/services/: time_service.c time_service.h
    ../../../bsw/mcal/ytm32b1le0/sdk/platform/devices/YTM32B1LE0/startup/: system_YTM32B1LE0.c system_YTM32B1LE0.h
    ../../../bsw/board/ytm32b1le0/bringup/: gpio_bringup.c gpio_bringup.h
