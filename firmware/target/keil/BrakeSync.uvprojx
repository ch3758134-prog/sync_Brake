# Keil uVision project BrakeSync.uvprojx, settings and files
target BrakeSync (6240000::V6.24::ARMCLANG)
  device: YTM32B1LE05 YTMicro
  pack: YTMicro.YTM32B1LE0_DFP.1.4.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) IROM2(0x10000000,0x800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BrakeSync +hex
  AfterMake: fromelf --bin --bincombined --output=Objects\@L.bin !L
  AfterMake: fromelf --m32 --m32combined --output=Objects\@L.srec !L
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: YTM32B1LE0,CPU_YTM32B1LE0,
  c include: ../../source;../../tests/target;../../platform/ytm32b1le0/config;../../platform/ytm32b1le0/startup;../../platform/ytm32b1le0;../../platform/ytm32b1le0/sdk/platform/drivers/src/clock/YTM32B1Lx;../../platform/ytm32b1le0/sdk/platform/drivers/src/pins;../../platform/ytm32b1le0/sdk/platform/drivers/src/dma;../../platform/ytm32b1le0/sdk/platform/drivers/src/uart;../../platform/ytm32b1le0/sdk/platform/drivers/inc;../../platform/ytm32b1le0/sdk/platform/devices/common;../../platform/ytm32b1le0/sdk/platform/devices;../../platform/ytm32b1le0/sdk/platform/devices/YTM32B1LE0/include;../../platform/ytm32b1le0/sdk/CMSIS/Core/Include;../../platform/ytm32b1le0/sdk/rtos/osif;../../source/BSW/Services/Scheduler;../../source/ASW/BrakeInput;../../source/ASW/BrakeControl;../../source/ASW/Diagnostics;../../source/ASW/Motion;../../source/ASW/SystemState;../../tests/target/legacy;../../source/BSW/EAL/Bluetooth/WLT8016;../../source/BSW/EAL/MotionSensor/BMA510;../../source/BSW/EAL/MotionSensor;../../source/BSW/EAL/MotionSensor/CanImu;../../source/BSW/MCAL/ADC;../../source/BSW/Services/Buffer;../../source/BSW/MCAL/CAN;../../source/BSW/MCAL/System;../../source/BSW/MCAL/I2C;../../source/BSW/MCAL/SPI;../../source/BSW/MCAL/Timer;../../source/BSW/MCAL/Common;../../source/BSW/MCAL/UART;../../platform/ytm32b1le0/sdk/platform/devices/YTM32B1LE0/startup;../../source/BSW/Services/EventLog;../../source/BSW/Services/Health;../../source/BSW/Services/Time;../../source/Common;../../source/BSW/MCAL/GPIO;../../source/BSW/MCAL/Clock;../../source/BSW/MCAL/UART;../../source/BSW/EAL/GPIO;../../source/BSW/EAL/Bluetooth/WLT8016;../../source/BSW/EAL/MotionSensor/BMA510
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ../../platform/ytm32b1le0/startup/yt_linker.scf
  link misc: --entry Reset_Handler --no_startup --diag_suppress=L6314W,L6221E,L6329W --keep=*(.isr_vector)
  group 01 Main
    ../../source/: main.c
  group 02 Common
    ../../source/Common/: bs_status.h bs_observation.h
  group 10 ASW / BrakeControl
    ../../source/ASW/BrakeControl/: bs_control_contract.h
  group 10 ASW / BrakeInput
    ../../source/ASW/BrakeInput/: brake_intent.c brake_intent.h
  group 10 ASW / Diagnostics
    ../../source/ASW/Diagnostics/: diagnostics.c diagnostics.h
  group 10 ASW / Motion
    ../../source/ASW/Motion/: motion_sample.c motion_sample.h motion_signal.c motion_signal.h
  group 10 ASW / SystemState
    ../../source/ASW/SystemState/: run_qualification.c run_qualification.h output_authorization.c output_authorization.h
  group 20 BSW / MCAL / ADC
    ../../source/BSW/MCAL/ADC/: drv_adc.h
  group 20 BSW / MCAL / CAN
    ../../source/BSW/MCAL/CAN/: drv_can.h drv_can_frame.c drv_can_port.h
  group 20 BSW / MCAL / Common
    ../../source/BSW/MCAL/Common/: drv_types.h
  group 20 BSW / MCAL / I2C
    ../../source/BSW/MCAL/I2C/: drv_i2c.h
  group 20 BSW / MCAL / SPI
    ../../source/BSW/MCAL/SPI/: drv_spi.h
  group 20 BSW / MCAL / System
    ../../source/BSW/MCAL/System/: drv_clock.h drv_reset.h
  group 20 BSW / MCAL / Timer
    ../../source/BSW/MCAL/Timer/: drv_timer.h mcal_time.h
  group 20 BSW / MCAL / UART
    ../../source/BSW/MCAL/UART/: drv_uart.h drv_uart_port.h
  group 21 BSW / EAL / Bluetooth
    ../../source/BSW/EAL/Bluetooth/WLT8016/: ble_serial.h
  group 21 BSW / EAL / MotionSensor
    ../../source/BSW/EAL/MotionSensor/: cdd_motion.h
    ../../source/BSW/EAL/MotionSensor/CanImu/: imu_can.h
    ../../source/BSW/EAL/MotionSensor/BMA510/: bma510.h
  group 22 BSW / Services / Buffer
    ../../source/BSW/Services/Buffer/: drv_byte_fifo.c drv_byte_fifo.h
  group 22 BSW / Services / EventLog
    ../../source/BSW/Services/EventLog/: diag_log.c diag_log.h
  group 22 BSW / Services / Health
    ../../source/BSW/Services/Health/: health_service.c health_service.h
  group 22 BSW / Services / Scheduler
    ../../source/BSW/Services/Scheduler/: app_scheduler.c app_scheduler.h
  group 22 BSW / Services / Time
    ../../source/BSW/Services/Time/: time_service.c time_service.h
  group 30 Platform / YCT Config
    ../../platform/ytm32b1le0/config/: clock_config.c clock_config.h pin_mux.c pin_mux.h interrupt_config.c interrupt_config.h dma_config.c dma_config.h uart_config.c uart_config.h sdk_project_config.h
  group 31 Platform / Startup
    ../../platform/ytm32b1le0/startup/: RamInit0.S RamInit1.c RamInit2.c startup.S vector.S vector_table_copy.c
  group 32 Platform / System
    ../../platform/ytm32b1le0/: system_init.c system_init.h system_time.c
  group 40 Vendor / CMSIS
    ../../platform/ytm32b1le0/sdk/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_ccarm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
  group 41 Vendor / Device
    ../../platform/ytm32b1le0/sdk/platform/devices/: callbacks.h devassert.h device_registers.h floats.h status.h
    ../../platform/ytm32b1le0/sdk/platform/devices/common/: core_common.h
    ../../platform/ytm32b1le0/sdk/platform/devices/YTM32B1LE0/include/: YTM32B1LE0.h YTM32B1LE0_features.h
    ../../platform/ytm32b1le0/sdk/platform/devices/YTM32B1LE0/startup/: system_YTM32B1LE0.c system_YTM32B1LE0.h
  group 42 Vendor / SDK Drivers
    ../../platform/ytm32b1le0/sdk/platform/drivers/inc/: clock.h clock_manager.h pins_driver.h interrupt_manager.h dma_driver.h uart_driver.h
    ../../platform/ytm32b1le0/sdk/platform/drivers/src/clock/YTM32B1Lx/: cfmu_hw_access.h clock_YTM32B1Lx.c clock_YTM32B1Lx.h cmu_hw_access.h ipc_hw_access.h scu_hw_access.h
    ../../platform/ytm32b1le0/sdk/platform/drivers/src/dma/: dma_driver.c dma_hw_access.c dma_hw_access.h dma_irq.c dma_irq.h
    ../../platform/ytm32b1le0/sdk/platform/drivers/src/interrupt/: interrupt_manager.c
    ../../platform/ytm32b1le0/sdk/platform/drivers/src/pins/: pins_driver.c pins_gpio_hw_access.h pins_port_hw_access.c pins_port_hw_access.h
    ../../platform/ytm32b1le0/sdk/platform/drivers/src/uart/: uart_driver.c uart_irq.c uart_irq.h uart_hw_access.h uart_hw_access.c
  group 43 Vendor / OSIF
    ../../platform/ytm32b1le0/sdk/rtos/osif/: osif.h osif_baremetal.c
  group 50 Test / Legacy GPIO
    ../../tests/target/legacy/: drv_gpio.h board_gpio_ids.h
  group 51 Test / Target
    ../../tests/target/: evb_app.c evb_app.h gpio_bringup.c gpio_bringup.h test_gpio.c test_gpio.h test_timebase.c test_timebase.h
  group 20 BSW / MCAL / GPIO
    ../../source/BSW/MCAL/GPIO/: mcal_gpio.c mcal_gpio.h
  group 20 BSW / MCAL / Clock
    ../../source/BSW/MCAL/Clock/: mcal_clock.c mcal_clock.h
  group 20 BSW / MCAL / UART Driver
    ../../source/BSW/MCAL/UART/: mcal_uart.c mcal_uart.h
  group 21 BSW / EAL / GPIO
    ../../source/BSW/EAL/GPIO/: eal_gpio.c eal_gpio.h
  group 21 BSW / EAL / WLT8016
    ../../source/BSW/EAL/Bluetooth/WLT8016/: wlt8016_transport.c wlt8016_transport.h
  group 21 BSW / EAL / BMA510
    ../../source/BSW/EAL/MotionSensor/BMA510/: bma510_device.c bma510_device.h
  group 51 Test / UART1
    ../../tests/target/: test_uart1.c test_uart1.h
